# Keil uVision project uart_echo.uvproj, settings and files
target uart_echo (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000ffff) IROM(0-0x3ffff) CLOCK(50000000) CPUTYPE("Cortex-M3")
  output: uart_echo
  AfterMake: fromelf --bin --output .\rvmdk\uart_echo.bin .\rvmdk\uart_echo.axf
  c flags: Optim=3 oTime=1 wLevel=2
  c define: rvmdk PART_LM3S8962
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: uart_echo.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: rit128x96x4.c OS.c OS_asm.s OSuart.c can_fifo.c ir.c servo.c
    ./: startup_rvmdk.S Lab7.c
    ../../../driverlib/: adc.c interrupt.c gpio.c ssi.c can.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
