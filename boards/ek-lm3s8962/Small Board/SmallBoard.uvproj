# Keil uVision project SmallBoard.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S2110 Luminary Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: SmallBoard
  c flags: Optim=1
  c include: ..;..\..\..;
  asm include: ..;..\..\..;
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: Startup.s Lab6.c
    ../drivers/: ping.c OS.c OSuart.c OS_asm.s ThreadStack.s can_fifo.c rit128x96x4.c
    ../../../driverlib/: adc.c
    ../../../driverlib/rvmdk/: driverlib.lib
